# Keil uVision project navigation.uvprojx, settings and files
target navigation (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: navigation +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,STM32F103xB,ARM_MATH_CM3
  c misc: --diag_suppress=2803,1,1035
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App;../Hardware;../Middle/FreeRTOS/include;../Middle/FreeRTOS/portable;../Control
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group FreeRTOS/Portable
    ../Middle/FreeRTOS/portable/: port.c
    ../Middle/FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/Source
    ../Middle/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Application/User/Core
    ../Core/Src/: Delay.c main.c gpio.c dma.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
    ../Core/Inc/: FreeRTOSConfig.h
  group Hardware
    ../Hardware/: Encoder.c Encoder.h Motor.c Motor.h MPU9520.c MPU9520.h MPU9520_Reg.h MyI2C.c MyI2C.h MySPI.c MySPI.h W25Q64.c W25Q64.h W25Q64_Ins.h Blueteeth.c Blueteeth.h
  group Control
    ../Control/: PID.c PID.h Angle.c Angle.h Position.c Position.h
  group App
    ../App/: Car.c Car.h
software components: CMSIS:DSP 1.5.1
